DEPENDS_append = " libbsd libunpriv"
LDFLAGS_append = " -lbsd -lprivilege"
