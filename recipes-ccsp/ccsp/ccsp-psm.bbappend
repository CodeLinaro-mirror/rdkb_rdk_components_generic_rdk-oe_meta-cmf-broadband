DEPENDS += "cjson"
DEPENDS_remove = "mountutils"

LDFLAGS += "-lcjson"
