DEPENDS += " halinterface"
