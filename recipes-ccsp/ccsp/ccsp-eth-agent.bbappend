CFLAGS_append = " -Wno-unused-variable -Wno-unused-function -Wno-implicit-function-declaration "
CFLAGS_aarch64_append = " -Werror=format-truncation=1 "
