DEPENDS += "libunpriv"
LDFLAGS += "-lprivilege"
