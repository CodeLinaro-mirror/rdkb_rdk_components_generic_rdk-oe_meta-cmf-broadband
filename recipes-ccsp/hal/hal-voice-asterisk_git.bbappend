RDEPENDS_${PN}_remove = "asterisk"
