#cpuprocanalyser build failure when compiled alone without needed dependency
DEPENDS += "libsyswrapper webconfig-framework"
