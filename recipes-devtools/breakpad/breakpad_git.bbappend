FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += " file://breakpad_processname_revised.patch"
